# Keil uVision project PP02_REMOTE_hal.uvprojx, settings and files
target PP02_REMOTE_hal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: PP02_REMOTE_hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP;../COM;../freeRTOS;../INF;../MID/freeRTOS;../MID;../MID/freeRTOS/include;../MID/freeRTOS/portable/RVDS/ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group MID/freeRTOS
    ../MID/freeRTOS/: FreeRTOSConfig.h
  group MID/freeRTOS/portable
    ../MID/freeRTOS/portable/MemMang/: heap_4.c
    ../MID/freeRTOS/portable/RVDS/ARM_CM3/: port.c
  group MID/freeRTOS/source
    ../MID/freeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group MID/freeRTOS/include
    ../MID/freeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group app
    ../APP/: App_data_process.c App_comm_data.c App_Display.c
  group inf
    ../INF/: SI24R1.c Inf_ip5305t.c Inf_key.c Inf_joystick.c
  group freeRTOS
    ../freeRTOS/: freeRTOS_task.c
  group com
    ../COM/: com_types.c
  group OLED
    ../INF/: Inf_font.c Inf_OLED.c
software components: CMSIS:CORE 4.3.0
